PACKAGE_INSTALL:append = " dropbear ssh-pubkey-server searcher-container searcher-container-network"

include lighthouse.inc

SRC_URI = "git://github.com/sigp/lighthouse;protocol=https;branch=stable"
SRCREV = "v7.0.1"
